# Repository Nanraka/ESP32_WROVER_iot_module

File README.md:

# ESP32_WROVER_iot_module

<br>
This board is ESP32 WROVER developer module.<br>

# Features
Unlike other boards, this board is designed to be used for IoT applications.<br>
There are no peripheral parts such as writing ICs, sensors, or tact switches, but a universal pattern is implemented, so that any necessary parts can be added.<br>

# How to use
Since this board is not equipped with a write IC, the following two procedures are used for writing.
1. Prepare a usb serial converter by yourself and connect Tx, Rx, Vcc, and GND on the board. Make sure that the logic voltage of the usb serial converter is 3.3v.
2. Press and hold the reset and boot buttons on the board.
3. Press the write button on the ArduinoIDE.
4. Release the reset button.
5. Release the boot button.

# Others
- The holes for mounting the board screws are 2 mm in diameter.
- The size of the board is designed as same size of the battery box. This board can receive voltage supply easily by soldering battery box pins.

## EAGLE design schematic/ESP32_WROVER_iot_module.brd

Parts:
C1, C2, C3: C-EUC0805K; C0805K
D1: LED_BLUE; LEDC1608X39N_B
JP1: PINHD-1X4; 1X04
JP2, JP3, JP4, JP5: PINHD-1X7; 1X07
JP6: PINHD-1X2; 1X02
R1, R2: R-US_R0603; R0603
SW1, SW2: TVAF06-A020B-R
SW3: SS-12D00G3
TP1, TP2, TP3, TP4, TP5, TP6, TP7, TP8, TP9, TP10, TP11, TP12, TP13, TP14, TP15, TP16, TP17, TP18, TP19, TP20, TP21, TP22, TP23, TP24, TP25, TP26, TP27, TP28, TP29, TP30, TP31, TP32, TP33, TP34, TP35, TP36, TP37, TP38, TP39, TP40, TP41, TP42, TP43, TP44, TP45, TP46, TP47, TP48, TP49, TP50, TP51, TP52, TP53, TP54, TP55, TP56, TP57, TP58, TP59, TP60, TP61, TP62, TP63, TP64, TP65, TP66, TP67, TP68, TP69, TP70, TP71, TP72, TP73, TP74, TP75, TP76, TP77, TP78, TP79, TP80, TP81, TP82, TP83, TP84, TP85, TP86, TP87, TP88, TP89, TP90, TP91, TP92, TP93, TP94, TP95, TP96, TP97, TP98, TP99, TP100, TP101, TP102, TP103, TP104, TP105, TP106, TP107, TP108, TP109, TP110: TESTPOINT_TPS-PAD-036; TESTPOINT_PAD-036
U1: LD1117S33TR; SOT-223
U2: ESP32-WROVER-B_(16MB); XCVR_ESP32-WROVER-B_(16MB)

Connections:
0: SW2.P$1, U2.25 (IO0/GPIO0/ADC2_CH1/TOUCH1/RTC_GPIO11/CL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)
2: JP4.5, U2.24 (IO2/GPIO2/ADC2_CH2/TOUCH2/RTC_GPIO12/HS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)
3.3V: C1.1, C3.1, JP1.1, JP2.2, JP3.7, JP4.2, R1.2, U1.2 (OUT), U1.4, U2.2 (3V3)
4: JP4.6, U2.26 (IO4/GPIO4/ADC2_CH0/TOUCH0/RTC_GPIO10/HS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)
5: JP3.2, U2.29 (IO5/GPIO5/VSPICS0/HS1_DATA6/EMAC_RX_CLK)
12: JP5.6, U2.14 (IO12/GPIO12/ADC2_CH5/TOUCH5/RTC_GPIO15/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)
13: JP4.3, U2.16 (IO13/GPIO13/ADC2_CH4/TOUCH4/RTC_GPIO14/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)
14: JP5.5, U2.13 (IO14/GPIO14/ADC2_CH6/TOUCH6/RTC_GPIO16/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)
15: JP4.4, U2.23 (IO15/GPIO15/ADC2_CH3/TOUCH3/MTDO/HSPICS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)
18: JP3.3, U2.30 (IO18/GPIO18/VSPICLK/HS1_DATA7)
19: JP3.4, U2.31 (IO19/GPIO19/VSPIQ/U0CTS/EMAC_TXD0)
21: JP3.5, U2.33 (IO21/GPIO21/VSPIHD/EMAC_TX_EN)
22: JP3.6, U2.36 (IO22/GPIO22/VSPIWP/U0RTS/EMAC_TXD1)
23: JP3.1, U2.37 (IO23/GPIO23/VSPID/HS1_STROBE)
25: JP5.2, U2.10 (IO25/GPIO25/DAC_1/ADC2_CH8/RTC_GPIO6/EM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)
26: JP5.3, U2.11 (IO26/DAC_2/ADC2_CH9/RTC_GPIO7/EMAC_RXD1)
27: JP5.4, U2.12 (IO27/GPIO27/ADC2_CH7/TOUCH7/RTC_GPIO17/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)
32: JP2.7, U2.8 (IO32/GPIO32/XTAL_32K_P/ADC1_CH4/TOUCH9/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)
33: JP5.1, U2.9 (IO33/GPIO33/XTAL_32K_N/ADC1_CH5/TOUCH8/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)
34: JP2.5, U2.6 (IO34/GPIO34/ADC1_CH6/RTC_GPIO4)
35: JP2.6, U2.7 (IO35/GPIO35/ADC1_CH7/RTC_GPIO5)
EN: R1.1, SW1.P$1, U2.3 (EN)
GND: C1.2, C2.2, C3.2, JP1.4, JP2.1, JP4.1, JP4.7, JP5.7, JP6.2, R2.1, SW1.P$2, SW2.P$2, TP98.1, U1.1 (ADJ/GND), U2.1 (GND), U2.15 (GND), U2.38 (GND), U2.39 (EP)
unnamed: D1.1 (C), R2.2
RXD: JP1.3, U2.34 (RXD0/GPIO3/U0RXD/CLK_OUT2)
SVN: JP2.4, U2.5 (SENSOR_VN/GPIO39/ADC1_CH3/RTC_GPIO3)
SVP: JP2.3, U2.4 (SENSOR_VP/GPIO36/ADC1_CH0/RTC_GPIO0)
TXD: JP1.2, U2.35 (TXD0/GPIO1/U0TXD/CLK_OUT3/EMAC_RXD2)
VCC: D1.2 (A), JP6.1, SW3.P$2, TP97.1
VIN: C2.1, SW3.P$3, U1.3 (IN)

Notes on the sheet:
チップ抵抗大きさ

Board: 2 copper layers, 74.2 x 77.2 mm, 127 parts (0 on the bottom side), 30 nets.

## Commit log

2023-12-04 First commit.
2023-12-04 Create LICENSE
2023-12-27 Update README.md, add fig
2023-12-27 Update README.md, change fig place
2023-12-29 Update README.md, add others
2023-12-31 Update README.md, add button fig
